# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=9
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\driver_on_chip
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group driver_on_chip
    ../../driver_on_chip/: adc.c pwm.c timer0.c timer1.c uart0.c
  group User
    ../../User/: main.c uart_data_handle.c key_driver.c ad_key.c user_test.c led.c battery_monitor.c bluetooth_ic_handle.c charge_det.c low_power.c bat_scan.c led_bat_lev.c
